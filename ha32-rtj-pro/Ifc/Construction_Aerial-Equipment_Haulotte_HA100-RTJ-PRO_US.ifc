Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2020-09-16T13:28:34
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Interface alternative d'export 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Sep 16 13:28:34 2020 * Host: N08 * Database: C:\Users\N~1\AppData\Local\Temp\{05DC1973-6D72-4665-A984-388FABFA2BF9}\ifc * Database version: 5507 * Database creation date: Wed Sep 16 13:28:26 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Sep 16 13:28:27 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Sep 16 13:28:27 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 m
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: -1.94916e-14 m
Graphismes(Type) - Couleur: 12632256; Epaisseur des lignes: 1; Motif des lignes: Tiret point; Symbole: Marqueur de niveau - Point triangulaire: Marqueur de niveau - Point triangulaire; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Ligne du Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre - Catégorie: Niveaux; Famille: Niveau: Ligne du Niveau; Famille et type: Niveau: Ligne du Niveau; ID du type: Niveau: Ligne du Niveau; Type: Niveau: Ligne du Niveau
Contraintes - Elévation: 0 m
Cotes - Hauteur de calcul: 0 m
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 0; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau

# IfcBuildingElementProxy: HA 100 RTJ PRO, Construction_Aerial-Equipment_Haulotte_HA100-RTJ-PRO_US:HA 100 RTJ PRO:4036201
In: Niveau 0
Type - Classification: E10 Equipement (Uniformat); Material: Metal - Haulotte - Red, Metal - Haulotte - Black, Haulotte, Metal - Haulotte - Yellow, Metal - Haulotte - Grey, Working_Area, Metal - Haulotte - White, Metal - Haulotte - Grey Dark
Type - Autre(Type) - Catégorie: Equipement spécialisé; Machine Weight: 20100 kg/44312.91 in; Nom de la famille: Construction_Aerial-Equipment_Haulotte_HA100-RTJ-PRO_US
Type - Données d'identification(Type) - Code d'assemblage: E10; Description: Diesel Articulating Boom; Description de l'assemblage: Equipement; Fabricant: Haulotte; Modèle: HA 100 RTJ PRO; Nom du type: HA 100 RTJ PRO; Note d'identification: 11000; Numéro OmniClass: 23.15.99.00; Product data url: https://www.bimobject.com/haulotte/product/ha32-rtj-pro; Titre OmniClass: Other Utility and Transportation Construction Products; URL: http://www.haulotte-usa.com/
Type - Données(Type) - Batteries: 12 V - 155 Ah; Drive Speed: 0.5-5 km/h/0.31-3.11 mph; Gradeability: 40%; Ground Clearance: 0.294 m/11,57 in; Height - Storage / Transport: 3.6 m/141.73 in; Height - Stowed: 3.655 m/143.90 in; Horizontal Outreach: 21.6 m/850.39 in; Jib Length: 1.2 m/47.24 in; Lenght - Storage/Transport: 8.9 m/350.39 in; Length - Stowed: 12.9 m/507.87 in; Lift Capacity: 250 kg/551.16 lb; Max Ground Pressure of Wheel on Paved Ground: 10.8 daN/cm2; Oscillating Angle: 2°/-2°; Platform Height: 29.8 m/1173.23 in; Platform Rotation: +90°/-90°; Platform Size: 2.44x0.915 m/96.06x36.02 in; Tailswing: 1.7 m/66.93 in 1.7 m/66.93 in; Tilt: 5°; Tires: 1.1x0.438 m/43.31x17.24 in; Turnable Rotation: 360°; Turning Radius - Inside: 2.75 m/108.27 in; Turning Radius - Outside: 5.075 m/199.80 in; Up and Over Clearance: 11.35 m/446.85 in; Vertical Jib Rotation Angle: +70°/-70 °; Wheelbase: 3.5 m/137.80 in; Width: 2.53 m/99.61 in; Working Height: 31.8 m/1251.97 in
Type - Général(Type) - Edition number: 1
Pset_BuildingElementProxyCommon - Reference: HA 100 RTJ PRO
Pset_ManufacturerTypeInformation - Manufacturer: Haulotte
Autre - A: 75 deg; Catégorie: Equipement spécialisé; Famille: Construction_Aerial-Equipment_Haulotte_HA100-RTJ-PRO_US: HA 100 RTJ PRO; Famille et type: Construction_Aerial-Equipment_Haulotte_HA100-RTJ-PRO_US: HA 100 RTJ PRO; H: 11.35 m; ID du type: Construction_Aerial-Equipment_Haulotte_HA100-RTJ-PRO_US: HA 100 RTJ PRO; Type: Construction_Aerial-Equipment_Haulotte_HA100-RTJ-PRO_US: HA 100 RTJ PRO
Construction - Axle Extension: yes; Boom Rotation Angle: 75 deg; Maximum Boom Articulation Point Height: 11.35 m; Platform Rotation Angle: 0 deg; Reach Diagram: yes; Telescopic Extend: 18.08 m; Turnable Rotation: 0 deg; Turning Radius: yes; Vertical Jib Rotation Angle: 60 deg; Working Area: yes
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0; Se déplace avec les éléments voisins: no
Cotes - Surface: 294.132 m2; Volume: 78.518 m3
Graphismes - Branding: yes
Phase de construction - Phase de création: Nouvelle construction
