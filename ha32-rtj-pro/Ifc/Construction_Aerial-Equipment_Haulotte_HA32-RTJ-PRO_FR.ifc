Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2020-09-16T13:36:17
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Interface alternative d'export 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Sep 16 13:36:17 2020 * Host: N08 * Database: C:\Users\N~1\AppData\Local\Temp\{A9E947FA-5A0F-4192-ACFC-DCE2B1501AB0}\ifc * Database version: 5507 * Database creation date: Wed Sep 16 13:35:42 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Sep 16 13:35:44 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Sep 16 13:35:44 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 m
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: -1.94916e-14 m
Graphismes(Type) - Couleur: 12632256; Epaisseur des lignes: 1; Motif des lignes: Tiret point; Symbole: Marqueur de niveau - Point triangulaire: Marqueur de niveau - Point triangulaire; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Ligne du Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre - Catégorie: Niveaux; Famille: Niveau: Ligne du Niveau; Famille et type: Niveau: Ligne du Niveau; ID du type: Niveau: Ligne du Niveau; Type: Niveau: Ligne du Niveau
Contraintes - Elévation: 0 m
Cotes - Hauteur de calcul: 0 m
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 0; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau

# IfcBuildingElementProxy: HA 32 RTJ PRO, Construction_Aerial-Equipment_Haulotte_HA32-RTJ-PRO_FR:HA 32 RTJ PRO:4036195
In: Niveau 0
Type - Classification: E10 Equipement (Uniformat); Material: Metal - Haulotte - Red, Metal - Haulotte - Black, Haulotte, Metal - Haulotte - Yellow, Metal - Haulotte - Grey, Working_Area, Metal - Haulotte - White, Metal - Haulotte - Grey Dark
Type - Autre(Type) - Catégorie: Equipement spécialisé; Nom de la famille: Construction_Aerial-Equipment_Haulotte_HA32-RTJ-PRO_FR
Type - Données d'identification(Type) - Code d'assemblage: E10; Description: Nacelle articulée diesel; Description de l'assemblage: Equipement; Fabricant: Haulotte; Modèle: HA 32 RTJ PRO; Nom du type: HA 32 RTJ PRO; Note d'identification: 11000; Numéro OmniClass: 23.15.99.00; Product data url: https://www.bimobject.com/haulotte/product/ha32-rtj-pro; Titre OmniClass: Other Utility and Transportation Construction Products; URL: http://www.haulotte.fr
Type - Données(Type) - Angle de Levage Pendulaire: +70°/-70 °; Angle de Rotation Plateforme: +90°/-90°; Angle de Rotation Tourelle: 360°; Angle D'oscillation: 2°/-2°; Batteries: 12 V - 155 Ah; Capacité Maximum: 250 kg/551.16 lb; Déport Arrière: 1.7 m/66.93 in 1.7 m/66.93 in; Déport Maximum: 21.6 m/850.39 in; Devers: 5°; Dimensions Plateforme: 2.44x0.915 m/96.06x36.02 in; Empattement: 3.5 m/137.80 in; Garde au Sol: 0.294 m/11,57 in; Hauteur de Transport: 3.6 m/141.73 in; Hauteur Plateforme: 29.8 m/1173.23 in; Hauteur Repliée: 3.655 m/143.90 in; Hauteur Travail: 31.8 m/1251.97 in; Largeur Hors Tout: 2.53 m/99.61 in; Longueur de Transport: 8.9 m/350.39 in; Longueur Hors Tout: 12.9 m/507.87 in; Longueur Pendulaire: 1.2 m/47.24 in; Masse Machine (CE): 20100 kg/44312.91 in; Pente Maximum: 40%; Pneus: 1.1x0.438 m/43.31x17.24 in; Point D'articulation: 11.35 m/446.85 in; Pression Max au Sol: 10.8 daN/cm2; Rayon de Braquage Exterieur: 5.075 m/199.80 in; Rayon de Braquage Interieur: 2.75 m/108.27 in; Vitesse de Translation: 0.5-5 km/h/0.31-3.11 mph
Type - Général(Type) - Edition number: 1
Pset_BuildingElementProxyCommon - Reference: HA 32 RTJ PRO
Pset_ManufacturerTypeInformation - Manufacturer: Haulotte
Autre - A: 75 deg; Catégorie: Equipement spécialisé; Famille: Construction_Aerial-Equipment_Haulotte_HA32-RTJ-PRO_FR: HA 32 RTJ PRO; Famille et type: Construction_Aerial-Equipment_Haulotte_HA32-RTJ-PRO_FR: HA 32 RTJ PRO; H: 11.35 m; ID du type: Construction_Aerial-Equipment_Haulotte_HA32-RTJ-PRO_FR: HA 32 RTJ PRO; Type: Construction_Aerial-Equipment_Haulotte_HA32-RTJ-PRO_FR: HA 32 RTJ PRO
Construction - Abaque de Travail: yes; Angle de Levage Flèche: 75 deg; Angle de Levage Pendulaire: 75 deg; Angle de Rotation Tourelle: 0 deg; Extension Essieux: yes; Hauteur Maxi Point D'articulation: 11.35 m; Rayon de Braquage Exterieur: yes; Rotation Panier: 0 deg; Sortie du Telescope: 18.08 m; Zone de Travail: yes
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0; Se déplace avec les éléments voisins: no
Cotes - Surface: 294.132 m2; Volume: 78.518 m3
Graphismes - Marque: yes
Phase de construction - Phase de création: Nouvelle construction
